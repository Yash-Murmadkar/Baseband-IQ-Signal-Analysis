options:
  parameters:
    generate_options: qt_gui
    id: ex1
    output_language: python
    title: Assignment 2 Symbol rate estimation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: r"C:\Users\yashm\Downloads\file92\file92.iq"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
